# IAR project flash-loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\application\include; ..\..\drivers\cmsis\core\include; ..\..\drivers\cmsis\device\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: flash-loader.srec
  ILINK.IlinkOutputFile: RT32F7_ExcludeSRAM2.out
  ILINK.IlinkIcfFile: linker-file\flash-loader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../../application/src/: __framework.c device_algorithm.c framework.s
